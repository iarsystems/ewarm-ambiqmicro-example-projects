# IAR project blinky.ewp, settings and files
configuration Flash Debug (ARM, debug)
  General.OGChipSelectEditMenu: APOLLO512-KBR AmbiqMicro APOLLO512-KBR
  General.RTConfigPath2: $TOOLKIT_DIR$/INC/c/DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCIncludePath2: $TOOLKIT_DIR$\inc\AmbiqMicro
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: blinky.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ./: blinky.c startup_iar.c
